require u-boot-stm-common.inc

SRCREV = "${AUTOREV}"
DEFAULT_PREFERENCE = "-1"

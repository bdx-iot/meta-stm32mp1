IMAGE_INSTALL:append = " \
	libgpiod spitools \
"

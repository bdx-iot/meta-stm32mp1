
PACKAGECONFIG_append_stm32mp1 = " examples libinput linuxfb fontconfig sql-sqlite gl gles2 eglfs"


SRCREV_stm32mp1 = "511646b8ac5c82f210b16920044465756913d238"

OS_RELEASE_FIELDS_append = " HOME_URL"
HOME_URL = "https://github.com/bdx-iot/meta-stm32mp1"
